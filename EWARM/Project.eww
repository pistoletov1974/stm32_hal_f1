<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STMF1_BOARD_HAL.ewp</path>
  </project>
  <batchBuild />
</workspace>
